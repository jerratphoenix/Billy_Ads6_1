IMAGE_INSTALL:append = " poweroff-manage "