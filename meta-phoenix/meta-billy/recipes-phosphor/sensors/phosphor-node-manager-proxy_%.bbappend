FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Adjust-the-max-of-the-Memory-Power-sensor.patch"
