FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI += "file://0001-Ping-signal-addr-0x30.patch"
