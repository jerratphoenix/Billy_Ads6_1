FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Extend-OEM-command-to-support-full-and-quiet-mode.patch \
            file://0002-Customize-PCIe-device-interface.patch \
           "

