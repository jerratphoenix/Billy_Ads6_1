FILESEXTRAPATHS:prepend:wolfpass := "${THISDIR}/${PN}:"
