FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Brightoncity-Fixed-BRIG-157-IPMI-Some-sensors-are-sh.patch"

