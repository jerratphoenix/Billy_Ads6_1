FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-BMC-Reset-Cause-for-cold-reset-command.patch"

