FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-restart_cause-in-situation-that-the-Host-off-and.patch"

