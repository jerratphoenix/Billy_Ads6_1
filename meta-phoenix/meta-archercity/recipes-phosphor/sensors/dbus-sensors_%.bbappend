FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Shorten-the-name-to-keep-the-length-below-16-as-much.patch"

