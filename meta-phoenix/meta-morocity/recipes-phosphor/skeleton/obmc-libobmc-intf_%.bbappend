FILESEXTRAPATHS:prepend:brightoncity := "${THISDIR}/${PN}:"
