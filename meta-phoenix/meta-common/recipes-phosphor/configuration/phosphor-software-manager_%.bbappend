FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Probe_fw_env.config_for_factory_reset.patch"

