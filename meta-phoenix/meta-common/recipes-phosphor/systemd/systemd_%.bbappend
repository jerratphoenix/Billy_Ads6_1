FILESEXTRAPATHS:append:= "${THISDIR}/files:"

SRC_URI:append = " \
    file://0000-Fix-ARP-Flux.patch \
    "

