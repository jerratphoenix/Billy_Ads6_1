FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://obmc-update.sh"
