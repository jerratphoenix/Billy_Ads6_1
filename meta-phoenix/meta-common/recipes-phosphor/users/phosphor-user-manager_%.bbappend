FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-PATCH-FIX-When-user-account-is-disable-can-still-log.patch"

