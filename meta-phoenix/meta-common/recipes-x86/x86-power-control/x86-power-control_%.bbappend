FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-state-machine-off-state.patch \
            file://0002-Fix-power-restore-policy-and-correct-service-name-fo.patch \
            "

